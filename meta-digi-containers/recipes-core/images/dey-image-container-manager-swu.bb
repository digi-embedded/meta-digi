#
# Copyright (C) 2026, Digi International Inc.
#

FILESEXTRAPATHS:prepend := "${THISDIR}/../../../meta-digi-dey/recipes-digi/swu-images/files:"

require recipes-digi/swu-images/swu.inc

IMG_NAME = "dey-image-container-manager"
