# Copyright (C) 2026, Digi International Inc.

require recipes-containers/lxc/lxc-cc-container-path.inc
