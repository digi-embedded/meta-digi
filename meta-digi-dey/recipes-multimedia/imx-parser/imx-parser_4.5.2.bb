# Copyright (C) 2013-2016 Freescale Semiconductor
# Copyright 2017-2018 NXP
# Released under the MIT license (see COPYING.MIT for the terms)

include imx-parser.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d"

SRC_URI[md5sum] = "9e0911bca999ad17a2c1d04379e8075a"
SRC_URI[sha256sum] = "e6d00ef760a7779846809b44dfbfabaee90678b229bc9a300c175088b7b2b537"

COMPATIBLE_MACHINE = "(mx6|mx7|mx8)"
