# Copyright (C) 2016, 2017 Digi International

FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"

SRC_URI += "file://0001-gstimxv4l2-map-dev-video1-to-dev-fb0.patch"
