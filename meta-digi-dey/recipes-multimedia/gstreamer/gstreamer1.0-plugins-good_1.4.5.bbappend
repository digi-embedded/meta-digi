# Copyright (C) 2015 Digi International

FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"

SRC_URI += "file://aacparse-Fix-aacparse-error-tolerance-issue.patch"
