# Copyright (C) 2020-2021 Digi International Inc.

require recipes-multimedia/gstreamer/gstreamer1.0-plugins-ugly_1.16.0.bb

SRC_URI[md5sum] = "01d3a24152cfd5eb27b1787d44b524c6"
SRC_URI[sha256sum] = "686644e45e08258ae240c4519376668ad8d34ea6d0f6ab556473c317bfb7e082"
