# Copyright (C) 2020 Digi International Inc.

PV = "1.16.0"

SRC_URI[md5sum] = "1ec343c58d4b17d682f7befa8453c11c"
SRC_URI[sha256sum] = "e30964c5f031c32289e0b25e176c3c95a5737f2052dfc81d0f7427ef0233a4c2"
