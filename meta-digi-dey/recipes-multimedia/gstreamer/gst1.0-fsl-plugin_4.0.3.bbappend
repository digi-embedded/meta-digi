# Copyright (C) 2015 Digi International

FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"

SRC_URI += "file://0001-gst1.0-fsl-plugin-fix-mutex-lock-unlock-problem.patch"
