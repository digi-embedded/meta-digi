# Copyright (C) 2015 Digi International

FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"

SRC_URI += "file://0005-Fix_alaw_mulaw_channel_position.patch"
