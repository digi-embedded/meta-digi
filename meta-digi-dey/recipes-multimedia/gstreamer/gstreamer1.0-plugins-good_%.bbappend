# Copyright (C) 2021 Digi International Inc.

PACKAGECONFIG_append_ccimx6ul = " vpx"
