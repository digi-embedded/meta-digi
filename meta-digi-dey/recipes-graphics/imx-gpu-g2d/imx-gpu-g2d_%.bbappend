# Copyright (C) 2018 Digi International

COMPATIBLE_MACHINE = "(ccimx6$)"
