# Copyright (C) 2021 Digi International

RDEPENDS:${PN}:remove:ccimx6ul = "matchbox-terminal"
