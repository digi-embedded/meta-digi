# Copyright (C) 2013, Digi International Inc.

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
