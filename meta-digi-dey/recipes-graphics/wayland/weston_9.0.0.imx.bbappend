# Copyright (C) 2020 Digi International.

SRC_URI_append_ccimx6 = " file://0001-libweston-g2d-renderer-try-re-adjusting-fb-if-the-FB.patch"
