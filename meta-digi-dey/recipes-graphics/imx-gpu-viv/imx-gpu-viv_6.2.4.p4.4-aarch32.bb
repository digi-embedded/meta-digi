require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3"

SRC_URI[md5sum] = "6964c366e3998c60ca1dae5d3e2da33c"
SRC_URI[sha256sum] = "9cf5528a0ad8c53b2bcba236cb6861f5ef0c0c0735b3de5bab1ed0697be7b770"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
