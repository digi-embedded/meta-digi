require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=6c12031a11b81db21cdfe0be88cac4b3"

SRC_URI[md5sum] = "0868b86e5368d35fb4f3eac89b67c43b"
SRC_URI[sha256sum] = "527cdef23d5c9980fcecd5404c42950bfb7af947ae7bd84483fef073703e0686"

COMPATIBLE_MACHINE = "(mx8)"
