require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d"

SRC_URI[md5sum] = "24b5cd3a0bec8f91d82f404c61c6f7a7"
SRC_URI[sha256sum] = "59ab4f99cb8455cdfabd9228e2066190bbc229f758425846c60e853c2f70c26f"

COMPATIBLE_MACHINE = "(mx6q|mx6dl|mx6sx|mx6sl|mx7ulp)"
