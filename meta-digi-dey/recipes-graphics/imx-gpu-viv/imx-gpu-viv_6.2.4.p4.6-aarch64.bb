require imx-gpu-viv-v6.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=fd4b227530cd88a82af6a5982cfb724d"

SRC_URI[md5sum] = "c0e0431e8d67e57301b7fa91369cd6c5"
SRC_URI[sha256sum] = "0b7eda7d702c06a2b5274b93d870e8370bc85961f6e98b8d41afcfc86e384d80"

COMPATIBLE_MACHINE = "(mx8)"
