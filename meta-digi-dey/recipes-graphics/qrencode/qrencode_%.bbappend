# Copyright (C) 2026, Digi International Inc.

PACKAGECONFIG += "tools"
