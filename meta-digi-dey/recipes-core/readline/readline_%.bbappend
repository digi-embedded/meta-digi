# Copyright (C) 2018 Digi International.

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
