# Copyright (C) 2025, Digi International Inc.

require recipes-core/images/dey-image-graphical.inc

DESCRIPTION = "DEY image with chromium browser"

GRAPHICAL_CORE = "chromium"

COMPATIBLE_MACHINE = "(ccimx95)"
