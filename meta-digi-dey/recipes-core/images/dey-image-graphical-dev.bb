#
# Copyright (C) 2012 Digi International.
#
require dey-image-graphical.bb

DESCRIPTION = "DEY SATO based graphical image suitable for development work."

IMAGE_FEATURES += "dev-pkgs"
