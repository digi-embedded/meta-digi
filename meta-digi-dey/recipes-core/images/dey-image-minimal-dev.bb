#
# Copyright (C) 2012 Digi International.
#
require dey-image-minimal.bb

DESCRIPTION = "DEY busybox based image (non graphical) suitable for development work."

IMAGE_FEATURES += "dev-pkgs"
