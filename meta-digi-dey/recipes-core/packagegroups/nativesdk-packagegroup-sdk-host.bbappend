# Copyright (C) 2014 Digi International.

RDEPENDS_${PN} += " \
    nativesdk-u-boot-mkimage \
"
