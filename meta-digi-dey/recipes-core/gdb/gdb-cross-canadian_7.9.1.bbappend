# Copyright (C) 2017 Digi International Inc.

FILESEXTRAPATHS_prepend := "${THISDIR}/${BP}:"

SRC_URI += "file://0001-Do-arm_abi-detection-for-ELFOSABI_GNU-binaries.patch"
