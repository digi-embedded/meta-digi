FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += " file://0001-gcancellable-Fix-minor-race-between-GCancellable-and.patch"
