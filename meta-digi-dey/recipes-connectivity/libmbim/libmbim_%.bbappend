# Copyright (C) 2017 Digi International Inc.

RDEPENDS_${PN} += "glibc-gconv-utf-16"
