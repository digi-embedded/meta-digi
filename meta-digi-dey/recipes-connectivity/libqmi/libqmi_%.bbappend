# Copyright (C) 2017 Digi International Inc.

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += " \
	file://0001-meta-digi-dey-Added-libqmi-patch-to-DMS-version-miss-match.patch \
"

