#
# Copyright (C) 2019, Digi International Inc.
#

RRECOMMENDS:${PN}:remove:class-target = " lvm2-udevrules"
