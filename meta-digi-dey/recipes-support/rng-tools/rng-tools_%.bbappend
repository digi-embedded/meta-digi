# Copyright (C) 2016 Digi International.

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
