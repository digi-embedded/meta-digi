# Copyright (C) 2025, Digi International Inc.

SRC_URI += " \
    file://0004-Revert-parser-set_find_path-properly-return-to-free-.patch \
"
