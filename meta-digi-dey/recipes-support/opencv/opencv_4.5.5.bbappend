# Copyright 2026 Digi International Inc.

SRC_URI:prepend = "git://github.com/opencv/opencv.git;name=opencv;branch=4.x;protocol=https "
SRC_URI:remove = "git://github.com/opencv/opencv.git;name=opencv;branch=master;protocol=https"
