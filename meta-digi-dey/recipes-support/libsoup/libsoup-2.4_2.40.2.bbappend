# Copyright (C) 2013 Digi International.

DEPENDS += "intltool-native"
