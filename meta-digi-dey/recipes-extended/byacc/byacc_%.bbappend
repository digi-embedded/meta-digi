# Copyright 2020, Digi International Inc.

BBCLASSEXTEND_append = " nativesdk"
