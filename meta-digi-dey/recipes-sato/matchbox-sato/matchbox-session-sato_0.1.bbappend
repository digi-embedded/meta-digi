# Copyright (C) 2014 Digi International.

FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"
