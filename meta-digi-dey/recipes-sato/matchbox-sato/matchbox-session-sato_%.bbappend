# Copyright (C) 2014, Digi International Inc.

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
