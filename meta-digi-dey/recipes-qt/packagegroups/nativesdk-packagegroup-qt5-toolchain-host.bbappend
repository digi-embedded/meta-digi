# Copyright (C) 2017, Digi International Inc.

RDEPENDS_${PN} += "nativesdk-python3-json"