# Copyright (C) 2022 Digi International

include nobranch.inc
