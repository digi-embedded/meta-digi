# Copyright (C) 2023, Digi International Inc.

BBCLASSEXTEND += "nativesdk"
