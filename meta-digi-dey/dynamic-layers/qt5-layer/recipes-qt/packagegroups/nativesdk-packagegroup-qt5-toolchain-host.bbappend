# Copyright (C) 2017, Digi International Inc.

RDEPENDS:${PN} += "nativesdk-python3-json"
