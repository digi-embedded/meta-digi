
# Remove dependency on qtgraphicaleffects for sololite
DEPENDS:remove:mx6sl-nxp-bsp = "qtgraphicaleffects"
RDEPENDS:${PN}:remove:mx6sl-nxp-bsp = "qtgraphicaleffects-qmlplugins"
