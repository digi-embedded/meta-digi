# Copyright (C) 2023, Digi International Inc.

RDEPENDS:packagegroup-x-linux-ai-tflite:remove:ccmp13 = " \
    tflite-cv-apps-image-classification-c++ \
    tflite-cv-apps-object-detection-c++ \
"

RDEPENDS:packagegroup-x-linux-ai-tflite-edgetpu:remove:ccmp13 = " \
    tflite-cv-apps-edgetpu-image-classification-c++ \
    tflite-cv-apps-edgetpu-object-detection-c++ \
"
