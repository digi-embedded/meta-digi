# Copyright (C) 2023 Digi International

SRCREV = "b3ccf36b718d16f5fb38ccfc2cccaf45c79854d8"

PACKAGECONFIG:append:mx93-nxp-bsp = " imxgpu imxg2d"

COMPATIBLE_MACHINE = "(imx-nxp-bsp)"
