# Copyright (C) 2023 Digi International

COMPATIBLE_MACHINE = "(imx-nxp-bsp)"
