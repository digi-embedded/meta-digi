# Copyright (C) 2021, Digi International Inc.

RRECOMMENDS:${PN}:ccimx6ul = ""
