# Copyright 2023 Digi International Inc.

#
# Reuse meta-freescale's imx-dsp-codec-ext_2.0.2.bb
#
require recipes-multimedia/imx-dsp/imx-dsp-codec-ext_2.0.2.bb

LIC_FILES_CHKSUM = "file://COPYING;md5=db4762b09b6bda63da103963e6e081de"

SRC_URI[md5sum] = "4619cebbad2f312b950a9ad2b2e30e24"
SRC_URI[sha256sum] = "89ac92b348aa70c81dcbf6a9ee4bc99bec56a491a89f5ba9854eab77e5fd4298"

COMPATIBLE_MACHINE = "(ccimx93)"
