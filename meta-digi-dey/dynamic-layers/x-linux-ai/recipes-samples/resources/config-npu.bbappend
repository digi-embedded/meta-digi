# Copyright (C) 2025, Digi International Inc.

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://patches/0001-config_board-fix-support-for-web-camera-with-STM32MP.patch \
"
