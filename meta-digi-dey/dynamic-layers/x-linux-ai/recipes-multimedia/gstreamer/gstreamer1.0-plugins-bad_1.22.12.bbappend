# Copyright (C) 2025, Digi International Inc.

# The "uvcsink" PACKAGECONFIG introduced by meta-st-x-linux-ai is lost due to
# the strict PACKAGECONFIG assignment above, so re-incorporate it here
PACKAGECONFIG:append = "uvcsink"
