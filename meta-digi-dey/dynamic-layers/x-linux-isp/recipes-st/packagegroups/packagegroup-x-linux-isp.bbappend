# Copyright (C) 2026, Digi International Inc.

# Manage to provide all framework tools base packages with overall one
RDEPENDS:packagegroup-x-linux-isp:remove = "x-linux-isp-tool"
