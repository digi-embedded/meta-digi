# Copyright 2024 Digi International Inc.

#
# Reuse meta-imx/meta-ml ethos-u-driver-stack_22.08.bb
#
require recipes-libraries/ethos-u-driver-stack/ethos-u-driver-stack_22.08.bb

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=e3fc50a88d0a364313df4b21ef20c29e"

SRCBRANCH = "lf-6.1.55_2.2.0"
SRCREV = "f8975c4d44e7893dcf106d4afaff55e30470b463"
