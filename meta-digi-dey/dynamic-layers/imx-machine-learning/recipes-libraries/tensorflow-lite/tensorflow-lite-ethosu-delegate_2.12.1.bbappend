# Copyright (C) 2024 Digi International Inc.

SRC_URI += "file://0001-Fix-hang-issue-with-multiple-tflite-context.patch"
