# Copyright (C) 2024, Digi International Inc.

BBCLASSEXTEND = "native"

# Clear machine restriction.
COMPATIBLE_MACHINE:remove = "(mx93-nxp-bsp)"

# Restrict the target build to specific machines.
COMPATIBLE_MACHINE:class-target = "(mx93-nxp-bsp)"
