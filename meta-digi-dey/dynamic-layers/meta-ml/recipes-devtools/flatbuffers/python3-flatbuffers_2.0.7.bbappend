# Copyright (C) 2024, Digi International Inc.

BBCLASSEXTEND = "native"
