# Copyright 2023 Digi International Inc.

PACKAGECONFIG_SOC:mx9-nxp-bsp:remove = "deepview-rt"
