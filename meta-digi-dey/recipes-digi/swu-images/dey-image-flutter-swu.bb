# Copyright (C) 2025, Digi International Inc.

require swu.inc
