FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"

PR_append_del = "+${DISTRO}.r0"
