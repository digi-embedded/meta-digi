#
# Copyright (C) 2012 Digi International.
#
require del-image-graphical.bb

DESCRIPTION = "DEL SATO based graphical image suitable for development work."

IMAGE_FEATURES += "dev-pkgs"
