EXTRA_OECONF += "\
		--disable-cdparanoia \
		--disable-examples \
		--disable-gio \
		--disable-gtk-doc \
		--disable-libvisual \
		--disable-rpath \
		--disable-x \
		--disable-xshm \
		--disable-xvideo \
		"
