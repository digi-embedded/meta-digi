EXTRA_OECONF += "\
		--disable-check \
		--disable-debug \
		--disable-failing-tests \
		--disable-rpath \
		--disable-shave \
		"
