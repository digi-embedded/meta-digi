EXTRA_OECONF += "\
		--disable-dvdlpcmdec \
		--disable-dvdsub \
		--disable-iec958 \
		--disable-rpath \
		"
