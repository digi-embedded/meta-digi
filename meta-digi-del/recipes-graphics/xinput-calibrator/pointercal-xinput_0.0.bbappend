FILESEXTRAPATHS_prepend := "${THISDIR}/${MACHINE}"

PR_append = "+${DISTRO}.r0"
