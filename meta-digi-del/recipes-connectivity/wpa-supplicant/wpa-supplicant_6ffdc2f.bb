# Copyright (C) 2012 Digi International.

require wpa-supplicant.inc

PR = "r0"

SRC_URI += "${DIGI_LOG_MIRROR}wpa_supplicant-${PV}.tar.gz"

SRC_URI[md5sum] = "99f8c4ce691e3c19b5cfc040efdadfe9"
SRC_URI[sha256sum] = "eaa94b450ed1e2e02f7f2ee31f86c873219603cd29d791c3dda5be0250ea7f7e"
