PR_del = "r0+${DISTRO}.0"
DEPENDS_append_del += "openssl"
LDFLAGS_del = "-lcap"

