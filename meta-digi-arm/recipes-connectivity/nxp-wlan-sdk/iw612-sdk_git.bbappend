# Copyright (C) 2023 Digi International.

RRECOMMENDS:${PN}:remove = "wireless-tools"
