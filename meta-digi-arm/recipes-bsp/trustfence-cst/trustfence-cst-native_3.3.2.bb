# Copyright (C) 2022, Digi International Inc.

require trustfence-cst-${PV}.inc

inherit native
