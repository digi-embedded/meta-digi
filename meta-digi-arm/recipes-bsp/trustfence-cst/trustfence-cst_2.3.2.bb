# Copyright (C) 2017, 2018 Digi International

require trustfence-cst.inc
