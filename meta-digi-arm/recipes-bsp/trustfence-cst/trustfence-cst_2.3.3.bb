# Copyright (C) 2017, 2018 Digi International

require trustfence-cst.inc

INSANE_SKIP_${PN} += "already-stripped"
