# Copyright (C) 2017 Digi International

require trustfence-cst-native.inc

INSANE_SKIP_${PN} += "already-stripped"
