# Copyright (C) 2022-2025, Digi International Inc.

require trustfence-cst-${PV}.inc

DEPENDS += "nativesdk-openssl"

inherit nativesdk
