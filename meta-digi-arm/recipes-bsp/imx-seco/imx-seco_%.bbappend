# Copyright (C) 2013-2021 Digi International.
require ccimx8x-seco-fw.inc
