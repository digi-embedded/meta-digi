# Copyright (C) 2023 Digi International.

require trustfence-stm-signtools.inc
inherit native
