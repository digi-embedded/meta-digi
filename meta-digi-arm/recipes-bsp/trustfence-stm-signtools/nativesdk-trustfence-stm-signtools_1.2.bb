# Copyright (C) 2023,2024 Digi International.

require trustfence-stm-signtools.inc
inherit nativesdk
