# Copyright (C) 2023-2026, Digi International Inc.

require trustfence-stm-signtools.inc
inherit native
