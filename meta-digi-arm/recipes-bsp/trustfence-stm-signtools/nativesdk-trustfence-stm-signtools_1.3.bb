# Copyright (C) 2023,2024, Digi International Inc.

require trustfence-stm-signtools.inc
inherit nativesdk
