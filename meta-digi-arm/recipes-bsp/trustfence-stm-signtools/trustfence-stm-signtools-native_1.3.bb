# Copyright (C) 2023, Digi International Inc.

require trustfence-stm-signtools.inc
inherit native
