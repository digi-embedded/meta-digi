# Copyright (C) 2018 Digi International Inc.

SC_FIRMWARE_NAME_ccimx8x = "mx8qx-a0-mek-scfw-tcm.bin"

COMPATIBLE_MACHINE = "(ccimx8x)"
