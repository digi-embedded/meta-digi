# Copyright (C) 2014 Digi International.

FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
