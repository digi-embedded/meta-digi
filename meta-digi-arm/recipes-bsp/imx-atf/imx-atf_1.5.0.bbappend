# Copyright (C) 2019 Digi International.

# Use the v4.14 ga BSP branch
SRCBRANCH = "imx_4.14.78_1.0.0_ga"
SRCREV = "d6451cc1e162eff89b03dd63e86d55b9baa8885b"
