# Copyright (C) 2021 Digi International.

# Make the package compatible with al platforms, not just with NXP's EVK
COMPATIBLE_MACHINE = "(mx8mp)"
