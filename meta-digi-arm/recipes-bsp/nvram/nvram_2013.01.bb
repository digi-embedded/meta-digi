PV = "2013.01"

require recipes-bsp/nvram/nvram.inc

COMPATIBLE_MACHINE = "(ccardimx28)"
