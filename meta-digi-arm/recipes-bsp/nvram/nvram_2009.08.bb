PV = "2009.08"

require recipes-bsp/nvram/nvram.inc

COMPATIBLE_MACHINE = "(ccimx5)"
