# Copyright (C) 2019,2020 Digi International

require digi-u-boot.inc

SRCBRANCH = "v2018.03/maint"
SRCREV = "baf4754bfca1581c73bb25f66da0d3b9f89f4fde"

COMPATIBLE_MACHINE = "(ccimx8x|ccimx8m)"
