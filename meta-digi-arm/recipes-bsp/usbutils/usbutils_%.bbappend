# Copyright (C) 2018, Digi International Inc.

RRECOMMENDS:${PN}:remove = "udev-hwdb"
