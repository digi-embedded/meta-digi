# Copyright (C) 2020 Digi International.

# wireless-regdb-static conflicts with wireless-regdb required by crda
RDEPENDS_packagegroup-base-wifi_remove = "wireless-regdb-static"
