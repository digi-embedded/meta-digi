PR_append = "digi.0"

SRC_URI_ccxmx53js = "${DIGI_LOG_MIRROR}/${PN}-${PV}.tar.gz"
SRC_URI_ccxmx51js = "${DIGI_LOG_MIRROR}/${PN}-${PV}.tar.gz"

SRC_URI_ccxmx53js[md5sum] = "c33df24405ef54cc55029d1f4a6c6230"
SRC_URI_ccxmx53js[sha256sum] = "2bb006d8eccb2938da868acc62f2d7620dffb40b070bf7b24479450da494a2a0"
SRC_URI_ccxmx51js[md5sum] = "c33df24405ef54cc55029d1f4a6c6230"
SRC_URI_ccxmx51js[sha256sum] = "2bb006d8eccb2938da868acc62f2d7620dffb40b070bf7b24479450da494a2a0"
