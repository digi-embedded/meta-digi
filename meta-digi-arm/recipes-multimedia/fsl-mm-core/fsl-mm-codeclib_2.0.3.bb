include fsl-mm-codeclib.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "c33df24405ef54cc55029d1f4a6c6230"
SRC_URI[sha256sum] = "2bb006d8eccb2938da868acc62f2d7620dffb40b070bf7b24479450da494a2a0"

COMPATIBLE_MACHINE = "(mx5)"
