# Copyright (C) 2012 Digi International
PR_append = "digi.0"

SRC_URI = "${DIGI_LOG_MIRROR}/${PN}-${PV}.tar.gz"

SRC_URI[md5sum] = "ab9fcca9d46a61c898862bcf18e3843c"
SRC_URI[sha256sum] = "a05cf407518528d10a2086e6952e5e93da3d311e1be0f8f20a8d765520afdd78"
