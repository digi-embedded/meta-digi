# Copyright (C) 2011 Freescale Semicondutor
# Copyright (C) 2012 Digi International
# Released under the MIT license (see COPYING.MIT for the terms)

require gst-fsl-plugin.inc

PR = "${INC_PR}.0"

SRC_URI[md5sum] = "ab9fcca9d46a61c898862bcf18e3843c"
SRC_URI[sha256sum] = "a05cf407518528d10a2086e6952e5e93da3d311e1be0f8f20a8d765520afdd78"
