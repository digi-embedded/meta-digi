require ${BPN}.inc

COMPATIBLE_MACHINE = "(ccmp2)"
