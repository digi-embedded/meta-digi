# Copyright (c) 2023, Digi International Inc.

PACKAGECONFIG:append:mx9-nxp-bsp = " dnn text"

COMPATIBLE_MACHINE = "(mx8-nxp-bsp|mx9-nxp-bsp)"
