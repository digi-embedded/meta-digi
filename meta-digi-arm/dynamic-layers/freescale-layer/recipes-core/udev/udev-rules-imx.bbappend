# Copyright (C) 2013-2021, Digi International Inc.
# Update 10-imx.rules
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
