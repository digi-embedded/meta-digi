# Copyright 2023 Digi International Inc.

LIC_FILES_CHKSUM:ccimx93 = "file://LICENSE.txt;md5=db4762b09b6bda63da103963e6e081de"

SRCREV:ccimx93 = "8d8b48c7c3d95b6c54093a09873ae796a0f09e8a"
