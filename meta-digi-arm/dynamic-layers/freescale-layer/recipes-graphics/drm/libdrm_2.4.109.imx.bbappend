# Copyright (c) 2023, Digi International Inc.

IMX_LIBDRM_SRC = "git://github.com/nxp-imx/libdrm-imx.git;protocol=https;nobranch=1"
SRCREV = "063bd699054866852ae182d2b31d4d3e7eae4f03"
