# Copyright (C) 2023, Digi International Inc.

DEPENDS:append:mx9-nxp-bsp = " imx-lib"

PLATFORM:mx9-nxp-bsp = "IMX8ULP"
