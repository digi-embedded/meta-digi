# Copyright (C) 2025, Digi International Inc.

#
# Reuse meta-freescale's optee-os_4.2.0.imx.bb
#
require recipes-security/optee-imx/optee-os_4.2.0.imx.bb

SRCBRANCH = "lf-6.6.52_2.2.0"
SRCREV = "60beb308810f9561a67fdb435388a64c85eb6dcb"
