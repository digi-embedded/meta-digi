# Copyright (C) 2025, Digi International Inc.

#
# Reuse meta-freescale's optee-client_4.2.0.imx.bb
#
require recipes-security/optee-imx/optee-client_4.2.0.imx.bb

SRCBRANCH = "lf-6.6.52_2.2.0"
SRCREV = "d221676a58b305bddbf97db00395205b3038de8e"
