# Copyright 2023 Digi International Inc.

#
# Reuse meta-freescale's optee-test_3.19.0.imx.bb
#
require recipes-security/optee-imx/optee-test_3.19.0.imx.bb

SRCBRANCH = "lf-6.1.22_2.0.0"
SRCREV = "c2c9f922044d2c8a7ab384812bb124c6da2b7888"

COMPATIBLE_MACHINE = "(ccimx93)"
