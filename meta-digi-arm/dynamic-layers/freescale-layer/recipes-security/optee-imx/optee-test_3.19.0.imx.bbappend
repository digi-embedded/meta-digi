# Copyright (C) 2023 Digi International

# Use NXP's lf-6.1.1_1.0.0 release for ccimx93
SRCBRANCH:ccimx93 = "lf-6.1.1_1.0.0"
SRCREV:ccimx93 = "7c314e6a0cec0ba19246eb4f1959859d7a6536d6"
