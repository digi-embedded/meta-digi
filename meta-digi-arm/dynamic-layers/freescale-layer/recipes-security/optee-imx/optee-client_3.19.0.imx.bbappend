# Copyright (C) 2023 Digi International

# Use NXP's lf-6.1.1_1.0.0 release for ccimx93
SRCBRANCH:ccimx93 = "lf-6.1.1_1.0.0"
SRCREV:ccimx93 = "01231b7a7ce03cdf9d3f48e7baa0bce17aac28f7"
