# Copyright (C) 2019 Digi International.

# The most recent version of this tool is unable to boot closed devices.
# Revert to the version that was used in DEY 2.4.
SRCREV = "349286e25c3fd9b2d31b31e962340123bbc62d44"
