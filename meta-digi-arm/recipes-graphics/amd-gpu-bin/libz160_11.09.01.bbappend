# Copyright (C) 2012 Digi International
PR_append = "+digi.0"

SRC_URI = "${DIGI_LOG_MIRROR}/libz160-bin-${PV}.tar.gz"

SRC_URI[md5sum] = "49b6d51e2ea6651107b08f43715c8c2e"
SRC_URI[sha256sum] = "43b1bebb2656d0c868c10f66ddc064c6324b74694daedfb3f542f93f438232c5"
