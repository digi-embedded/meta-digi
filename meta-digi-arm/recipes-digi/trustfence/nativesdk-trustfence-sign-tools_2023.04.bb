# Copyright (C) 2024, Digi International Inc.

require nativesdk-trustfence-sign-tools_git.bb

SRCBRANCH = "v2023.04/maint"
SRCREV = "b04f8a114dde1ac86efa220eb5356a72d32bdbb6"
