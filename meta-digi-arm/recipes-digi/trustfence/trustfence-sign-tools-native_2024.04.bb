# Copyright (C) 2024, Digi International Inc.

require trustfence-sign-tools-native_git.bb

SRCBRANCH = "v2024.04/master"
SRCREV = "${AUTOREV}"
