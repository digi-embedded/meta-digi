# Copyright (C) 2024, Digi International Inc.

require trustfence-sign-tools-native_git.bb

SRCBRANCH = "v2023.04/maint"
SRCREV = "87dc53402fca01e327b49d7b13bc0feb041db418"
