# Copyright (C) 2024, Digi International Inc.

require nativesdk-trustfence-sign-tools_git.bb

SRCBRANCH = "v2024.04/master"
SRCREV = "${AUTOREV}"
