# Copyright (C) 2020 Digi International

require recipes-kernel/linux/linux-dey-src.inc

COMPATIBLE_MACHINE = "(ccimx6ul|ccimx8x|ccimx8m)"
