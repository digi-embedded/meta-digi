# Copyright (C) 2019,2020 Digi International

require recipes-kernel/linux/linux-imx-headers.inc

COMPATIBLE_MACHINE = "(ccimx6ul|ccimx8x|ccimx8m)"
