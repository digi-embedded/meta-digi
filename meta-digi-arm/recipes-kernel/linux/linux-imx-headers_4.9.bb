# Copyright (C) 2019 Digi International

require recipes-kernel/linux/linux-imx-headers.inc

COMPATIBLE_MACHINE = "(ccimx6)"
